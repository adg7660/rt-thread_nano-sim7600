# Keil uVision project stm32l151rct_rt-thread_nano.uvprojx, settings and files
target stm32l151rct_rt-thread_nano (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L151RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32l151rct_rt-thread_nano
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L151xC, USE_HAL_DRIVER, USE_FULL_ASSERT
  c include: ..\..\sources\apps\inc;..\..\sources\board\inc;..\..\sources\board\mcu\CMSIS;..\..\sources\board\mcu\CMSIS\Include;..\..\sources\board\mcu\STM32L1xx_HAL_Driver\Inc;..\..\sources\board\mcu\STM32L1xx_HAL_Driver\Inc\Legacy;..\..\sources\board\inc;..\..\sources\peripherals\inc;..\..\sources\rt-thread_nano\components\finsh;..\..\sources\rt-thread_nano\include;..\..\sources\rt-thread_nano\include\libc;..\..\sources\rt-thread_nano\include;..\..\sources\rt-thread_nano\components\net\at\include;..\..\sources\rt-thread_nano\components\net\at\at_socket;..\..\sources\rt-thread_nano\components\drivers\include;..\..\sources\rt-thread_nano\components\drivers\include\ipc;..\..\sources\rt-thread_nano\components\net\sal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep *.o(.rti_fn.*)
  group apps
    ../../sources/apps/src/: main.c stm32l1xx_it.c
  group board
    ../../sources/board/src/: board.c gpio.c gpio-board.c usart.c utilities.c
  group cmsis
    ../../sources/board/mcu/CMSIS/: system_stm32l1xx.c startup_stm32l151xc.s
  group peripherals
    ../../sources/peripherals/src/: at_socket_sim7600ce.c
  group rt-thread/src
    ../../sources/rt-thread_nano/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group rt-thread/libcpu/cortex-m3
    ../../sources/rt-thread_nano/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group rt-thread/components/finsh
    ../../sources/rt-thread_nano/components/finsh/: cmd.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group STM32L1xx_HAL_Driver
    ../../sources/board/mcu/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c
  group rt-thread/components/net/at
    ../../sources/rt-thread_nano/components/net/at/src/: at_base_cmd.c at_cli.c at_client.c at_server.c at_utils.c
    ../../sources/rt-thread_nano/components/net/at/at_socket/: at_socket.c
    ../../sources/rt-thread_nano/components/net/sal/: sal_ipaddr.c
  group rt-thread/components/drivers
    ../../sources/rt-thread_nano/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
